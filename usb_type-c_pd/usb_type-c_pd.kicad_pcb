# Repository bols-blue-org/Kicad-project

## KiCad design usb_type-c_pd/usb_type-c_pd.kicad_pcb

Board: 2 copper layers, 4 parts (0 on the bottom side), 2 nets, no tracks yet.

Parts:
Q1: Q_PMOS_GSD; SOT-23
Q2, Q3: STL6P3LLH6; TRANS_STL6P3LLH6
U1: ST1S10PHR; TI_SO-PowerPAD-8

Connections:
unnamed: Q2.1, Q2.2, Q2.3
unnamed: Q3.1, Q3.2, Q3.3

## KiCad design drone_battery_series_circuit/drone_battery_series_circuit.kicad_pcb

Parts:
J1, J2: Barrel_Jack_MountingPin; XT90
J3: plus +; R6-bolt
J4, J5, J6, J7: Conn_01x01_Male; MountingHole_2.7mm_M2.5
J8: minus -; R6-bolt

Connections:
GND: J2.2, J8.1
unnamed: J1.2, J2.1
VCC: J1.1, J3.1

Board: 2 copper layers, 8 parts (0 on the bottom side), 3 nets, no tracks yet.

## KiCad design LTC485/LTC485.kicad_pcb

File LTC485/Readme.rst:

===========================
LTC485
===========================

LTC485 を使ったRS458をシリアルに変換するボード

Parts:
J1: I2C; PinHeader_1x02_P2.54mm_Vertical
J2: Sensor; PinHeader_1x02_P2.54mm_Vertical
U1: ATtiny85-20PU; DIP-8_W7.62mm
U2: SN75176AP; DIP-8_W7.62mm

Connections:
/SCL: J1.1, U1.7 (PB2)
/SDA: J1.2, U1.5 (AREF/PB0)
unnamed: J2.1, U2.7 (B)
unnamed: J2.2, U2.6 (A)
unnamed: U1.2 (XTAL1/PB3), U2.2 (~RE), U2.3 (DE)
unnamed: U1.3 (XTAL2/PB4), U2.1 (R)
unnamed: U1.4 (GND), U2.5 (GND)
unnamed: U1.6 (PB1), U2.4 (D)
unnamed: U1.8 (VCC), U2.8 (VCC)

Notes on the sheet:
SN75176BPはLTC485とコンパチなので今回はLTC485を使う

Board: 2 copper layers, 4 parts (0 on the bottom side), 9 nets, no tracks yet.

## KiCad design razpi-hat/razpi-hat.kicad_pcb

Schematic: razpi-hat.sch

Parts:
C1, C2: CP; CP_Radial_D8.0mm_P3.80mm
J1: Sensor; PhoenixContact_MCV_1,5_4-G-3.81_1x04_P3.81mm_Vertical
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
U1: ATtiny85-20PU; DIP-8_W7.62mm
U2: SN75176AP; DIP-8_W7.62mm
U3: MPM82

Connections:
+12V: C1.1, J1.1, U3.3 (Vin)
/A: J1.3, U2.6 (A)
/B: J1.2, U2.7 (B)
/GPIO2(SDA1): P1.3, U1.5 (AREF/PB0)
/GPIO3(SCL1): P1.5, U1.7 (PB2)
/GPIO4(GCLK): P1.7
/GPIO5: P1.29
/GPIO6: P1.31
/GPIO7(SPI1_CE_N): P1.26
/GPIO8(SPI0_CE_N): P1.24
/GPIO9(SPI0_MISO): P1.21
/GPIO10(SPI0_MOSI): P1.19
/GPIO11(SPI0_SCK): P1.23
/GPIO12(PWM0): P1.32
/GPIO13(PWM1): P1.33
/GPIO14(TXD0): P1.8
/GPIO15(RXD0): P1.10
/GPIO16: P1.36
/GPIO17(GEN0): P1.11
/GPIO18(GEN1)(PWM0): P1.12
/GPIO19(SPI1_MISO): P1.35
/GPIO20(SPI1_MOSI): P1.38
/GPIO21(SPI1_SCK): P1.40
/GPIO22(GEN3): P1.15
/GPIO23(GEN4): P1.16
/GPIO24(GEN5): P1.18
/GPIO25(GEN6): P1.22
/GPIO26: P1.37
/GPIO27(GEN2): P1.13
/ID_SC: P1.28
/ID_SD: P1.27
GND: C1.2, C2.2, J1.4, P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, U1.4 (GND), U2.5 (GND), U3.4 (P-GND), U3.5 (S-GND)
unnamed: U1.2 (XTAL1/PB3), U2.2 (~RE), U2.3 (DE)
unnamed: U1.3 (XTAL2/PB4), U2.1 (R)
unnamed: U1.6 (PB1), U2.4 (D)

Notes on the sheet:
ID_SD and ID_SC PINS: These pins are reserved for HAT ID EEPROM. At boot time this I2C interface will be interrogated to look for an EEPROM that identifes the attached board and allows automagic setup of the GPIOs (and optionally, Linux drivers). DO NOT USE these pins for anything other than attach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
Mounting Holes
SN75176BPはLTC485とコンパチなので今回はLTC485を使う

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
Board: 2 copper layers, 65.0 x 56.0 mm, 11 parts (1 on the bottom side), 11 nets.

## KiCad design loadcell2/SparkFun_HX711_Load_Cell.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF; 0603-CAP
C6, C7: 10uF; 1210
FID1, FID2: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
J1: M05PTH; 1X05
JP2: M02PTH; 1X02
JP4: M05PTH; 1X05
L1: 3.3uH; 0805
LOGO1: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO3: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
Q1: MMBT4403; SOT23-3
R1: 20k; 0603-RES
R2: 8.2K; 0603-RES
R3, R4: 100; 0603-RES
R5: 10K; 0603-RES
SJ2: JUMPER-PAD-2-NC_BY_TRACE; PAD-JUMPER-2-NC_BY_TRACE_YES_SILK
STANDOFF1, STANDOFF2, STANDOFF3, STANDOFF4: STAND-OFF
U1: HX711; SO16
U7: OSHW-LOGOS; OSHW-LOGO-S
U$1: REVISION

Connections:
/A+: JP4.2, R4.1
/A-: JP4.3, R3.1
/AVDD: C3.1, C7.1, JP4.5, L1.1
/B+: JP2.1, U1.10 (INB+)
/B-: JP2.2, U1.9 (INB-)
/DAT: J1.3, U1.12 (DOUT)
/SCK: J1.4, U1.11 (PD_SCK)
GND: C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, J1.5, JP4.1, JP4.4, R2.1, SJ2.1, U1.5 (AGND), U1.14 (XI)
unnamed: C1.1, R3.2, U1.7 (INA-)
unnamed: C1.2, R4.2, U1.8 (INA+)
unnamed: C2.2, U1.6 (VBG)
unnamed: L1.2, Q1.3 (C), R1.2, U1.3 (AVDD)
unnamed: Q1.1 (B), U1.2 (BASE)
unnamed: R1.1, R2.2, U1.4 (VFB)
unnamed: R5.1, SJ2.2, U1.15 (RATE)
VCC: C5.1, C6.1, J1.2, Q1.2 (E), R5.2, U1.1 (VSUP)
VDD: C4.1, J1.1, U1.16 (DVDD)

Notes on the sheet:
VCC: 2.7-5.5V
VBG = 1.25V
AVDD = VBG(R1+R2)/R2
Default: Closed - Data rate set to 10SPS
Open jumper to set to 80SPS Increases noise per read
Red
Black
White
Green or Blue
Common Load Cell Colors:
IO: 2.7-5.5V
Shield
Yellow
VDD: 2.7-5.5V
VCC vs VDD: VCC is the main supply voltage, while VDD sets the digital logic voltage reference and should be connected to microcontroller supply voltage, or shorted to VCC.
Alex Wende
N. Seidle
v11

Board: 2 copper layers, 30.5 x 22.9 mm, 30 parts (0 on the bottom side), 17 nets.

## Commit log

2020-02-25 モータードライバDRV8832追加
2020-02-25 ロードセルのサンプル用の回路図を追加
2020-02-25 おそらく何もしていないであろうロードセルのプロジェクト
2020-03-25 MPM82のシンボルとフットプリントの追加 razpi-hat の追加
2021-01-06 new files
2021-03-06 LC485 ディレクトリの説明追加
2021-03-06 ディレクトリと説明を追加

Notices in the files:
parts and their libraries:
https://creativecommons.org/licenses/by-sa/4.0
Released under the Creative Commons Attribution Share-Alike 4.0 License
